# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, __RTTHREAD__, STM32L475xx, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\extension;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\CubeMX_Config\Inc;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\components\finsh;.;..\..\..\include;..\libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc;..\libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include;..\libraries\STM32L4xx_HAL\CMSIS\Include;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: stdlib.c time.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: dataqueue.c ringblk_buf.c waitqueue.c workqueue.c completion.c pipe.c ringbuffer.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l475xx.s
    board/CubeMX_Config/Src/: stm32l4xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: scheduler.c device.c thread.c mem.c kservice.c object.c idle.c mempool.c irq.c timer.c components.c clock.c ipc.c
  group Libraries
    ../libraries/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_cryp.c stm32l4xx_hal_uart.c stm32l4xx_hal_usart.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_crc.c stm32l4xx_hal.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_comp.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_cryp_ex.c
    ../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c

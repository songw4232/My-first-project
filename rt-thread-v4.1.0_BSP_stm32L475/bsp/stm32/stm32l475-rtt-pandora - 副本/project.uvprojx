# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, __RTTHREAD__, STM32L475xx, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: packages\aht10-v2.1.0;.;applications;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\extension;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;board;board\CubeMX_Config\Inc;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;board\ports\lcd;..\..\..\components\finsh;packages\FlexibleButton-v1.0.0;.;..\..\..\include;..\libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc;..\libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include;..\libraries\STM32L4xx_HAL\CMSIS\Include;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc;packages\qrcode-latest;..\..\..\components\drivers\sensors;..\..\..\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  group aht10
    packages/aht10-v2.1.0/: sensor_asair_aht10.c aht10.c
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: stdlib.c time.c
  group CPU
    ../../../libcpu/arm/common/: div0.c backtrace.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/ipc/: dataqueue.c ringbuffer.c waitqueue.c ringblk_buf.c workqueue.c pipe.c completion.c
    ../../../components/drivers/misc/: rt_drv_pwm.c pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_flash_sfud.c
  group Drivers
    board/ports/: drv_sensor_port.c drv_usart2_test.c drv_key.c drv_qspi_flash.c
    board/CubeMX_Config/Src/: stm32l4xx_hal_msp.c
    ../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l475xx.s
    board/: board.c
    ../libraries/HAL_Drivers/: drv_qspi.c drv_gpio.c drv_spi.c drv_soft_i2c.c drv_common.c drv_usart.c drv_pwm.c drv_hwtimer.c
    board/ports/lcd/: drv_lcd.c
    board/ports/lcd/demo/: lcd_sample.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group flex_button
    packages/FlexibleButton-v1.0.0/: flexible_button.c
  group Kernel
    ../../../src/: scheduler.c kservice.c components.c mem.c thread.c clock.c timer.c irq.c device.c mempool.c idle.c object.c ipc.c
  group Libraries
    ../libraries/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_cryp.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_usart.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_lptim.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal.c stm32l4xx_hal_comp.c stm32l4xx_hal_qspi.c stm32l4xx_hal_exti.c stm32l4xx_hal_rng.c stm32l4xx_hal_crc.c stm32l4xx_hal_uart_ex.c
    ../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group qrcode
    packages/qrcode-latest/: qrcode.c
  group Sensors
    ../../../components/drivers/sensors/: sensor_cmd.c sensor.c
